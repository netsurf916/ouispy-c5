## main/Kconfig.projbuild
```kconfig
menu "OUI-SPY C5 Configuration"

    comment "Passive WiFi OUI detection currently uses compile-time channel and timing settings in scan.c."

endmenu
```
